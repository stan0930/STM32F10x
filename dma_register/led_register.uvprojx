# Keil uVision project led_register.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\User\hardware\UTIL;.\User\hardware\LED;.\User\hardware\KEY;.\User\hardware\USART;.\User\hardware\I2C;.\User\hardware\m24co2;.\User\hardware\dma
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
    ./User/hardware/UTIL/: delay.c
  group Hardware/LED
    ./User/hardware/LED/: led.c led.h
  group Hardware/KEY
    ./User/hardware/KEY/: key.c key.h
  group Hardware/USART
    ./User/hardware/USART/: usart.c usart.h
  group Hardware/I2C
    ./User/hardware/I2C/: I2C.c I2C.h
  group Interface/EEPROM
    ./User/hardware/m24co2/: m24c02.c m24c02.h
  group Hardware/DMA
    ./User/hardware/dma/: dma.c dma.h
