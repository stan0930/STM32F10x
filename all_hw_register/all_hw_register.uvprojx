# Keil uVision project all_hw_register.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: all_hw_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start; .\User;.\User\hardware\UTIL;.\User\hardware\USART;.\User\hardware\adc_single;.\User\hardware\adc_dma;.\User\hardware\dma_usart;.\User\hardware\i2c;.\User\hardware\eeprom_m24c02;.\User\hardware\key;.\User\hardware\led;.\User\hardware\pwm_cycle_tim4;.\User\hardware\pwm_cycle_tim5;.\User\hardware\pwm_duty_tim4;.\User\hardware\pwm_duty_tim5;.\User\hardware\spi_soft;.\User\hardware\spi;.\User\hardware\w25q32;.\User\hardware\tim1;.\User\hardware\tim5_breathe;.\User\hardware\tim6
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group Hardware/UTIL
    ./User/hardware/UTIL/: delay.c delay.h
  group Hardware/USART
    ./User/hardware/USART/: usart.c usart.h
  group Hardware/spi
    ./User/hardware/spi/: spi.c spi.h
  group Hardware/w25q32
    ./User/hardware/w25q32/: w25q32.c w25q32.h
